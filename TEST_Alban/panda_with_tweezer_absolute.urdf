Commit message: working load of urdf collision capsules

File: TEST_Alban/panda_with_tweezer_absolute.urdf (robot description, URDF)
Before this commit: robot panda, 21 links, 20 joints
Links:
- removed link world
Joints:
- removed joint panda_joint_world
